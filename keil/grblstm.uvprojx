# Keil uVision project grblstm.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: grblstm
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,STM32F103C8
  c misc: --diag_suppress=1295
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries;..\grbl;..\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../grbl/: main.c
    ../src/: main1.c
  group dev
    ../src/: uartX.c uartX.h
  group grbl-c
    ../grbl/: coolant_control.c eeprom.c gcode.c jog.c limits.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c
  group grbl-h
    ../grbl/: config.h coolant_control.h cpu_map.h defaults.h eeprom.h gcode.h grbl.h jog.h limits.h motion_control.h nuts_bolts.h planner.h print.h probe.h protocol.h report.h serial.h settings.h spindle_control.h stepper.h system.h
  group CMSIS
    ../Libraries/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_it.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
